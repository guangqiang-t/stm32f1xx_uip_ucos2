# Keil uVision project ucos2_uip_tcp_udp.uvprojx, settings and files
target Ton (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucos2_uip_tcp_udp +hex
  c flags: Optim=3 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\startup;..\cmsis\CoreSupport;..\cmsis\DeviceSupport\ST\STM32F10x;..\library\inc;..\library\src;..\bsp;..\os\config;..\os\core;..\os\cpu;..\os\ports;..\os\lib;..\os_app;..\uip-1.0\uip;..\uip-app;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../startup/: startup_stm32f10x_md.s
  group cmsis
    ../cmsis/CoreSupport/: core_cm3.c
    ../cmsis/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h
  group library
    ../library/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group bsp
    ../bsp/: bsp.h bsp_led.c bsp_systick.c bsp_usart.c bsp_enc28j60.c bsp_spi.c bsp_pwm.c bsp_sw.c bsp_74hc595.c bsp_logic.c bsp_temp.c
  group ucosii_config
    ../os/config/: includes.h os_cfg.h
  group ucosii_ports
    ../os/ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group ucosii_core
    ../os/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucosii_app
    ../os_app/: app_mian.c os_app.h
  group uip
    ../uip-1.0/uip/: psock.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uip_app
    ../uip-app/: tapdev.c timer.c uip_user_call.c uip-conf.h
  group user
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h get_arg.c
software components: CMSIS:CORE 5.0.1
